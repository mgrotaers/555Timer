.title KiCad schematic
.include "C:\Users\Laptop\Documents\CAD_Drawings\KiCAD\KiCad-Spice-Library-master\Models\Transistor\BJT\BJTN.LIB"
.include "C:\Users\Laptop\Documents\CAD_Drawings\KiCAD\KiCad-Spice-Library-master\Models\Transistor\BJT\BJTP.LIB"
.include "components.lib"
Vcc1 /555TimerChip/Pin_Reset GND pwl(0 0 100m 0 101m 5 1900m 5 1901m 0 2000m 0)
Rt2 GND /555TimerChip/Pin_Threshold 100k
Rt1 /555TimerChip/Pin_Threshold /555TimerChip/Pin_Reset 100k
Ct2 /555TimerChip/Pin_FMCV GND 0.01u
Rtl1 GND /output 1meg
Vint1 Net-_Ct1-Pad2_ GND sin(0 5 5)
Ct1 /555TimerChip/Pin_Threshold Net-_Ct1-Pad2_ 0.01
R10 Net-_Q19A1-Pad1_ Net-_Q18-Pad1_ 7k
R1 /555TimerChip/Pin_Reset Net-_Q5-Pad3_ 4.7k
R2 /555TimerChip/Pin_Reset Net-_Q6-Pad3_ 830
R3 /555TimerChip/Pin_Reset Net-_Q8-Pad3_ 4.7k
R4 /555TimerChip/Pin_Reset Net-_Q9-Pad3_ 1k
Q5 Net-_Q1-Pad3_ Net-_Q1-Pad3_ Net-_Q5-Pad3_ BC327
Q6 Net-_Q15-Pad1_ Net-_Q1-Pad3_ Net-_Q6-Pad3_ BC327
Q7 GND Net-_Q3-Pad1_ Net-_Q6-Pad3_ BC327
Q8 Net-_Q3-Pad1_ Net-_Q3-Pad1_ Net-_Q8-Pad3_ BC327
Q9 Net-_Q11-Pad3_ Net-_Q19A1-Pad1_ Net-_Q9-Pad3_ BC327
Q1 Net-_Q1-Pad1_ /555TimerChip/Pin_Threshold Net-_Q1-Pad3_ BC337
Q2 Net-_Q1-Pad3_ Net-_Q1-Pad1_ Net-_Q2-Pad3_ BC337
Q3 Net-_Q3-Pad1_ Net-_Q3-Pad2_ Net-_Q2-Pad3_ BC337
Q4 Net-_Q3-Pad1_ /555TimerChip/Pin_FMCV Net-_Q3-Pad2_ BC337
R5 Net-_Q2-Pad3_ GND 10k
Q11 Net-_Q10-Pad1_ Net-_Q10-Pad3_ Net-_Q11-Pad3_ BC327
Q12 GND Net-_Q12-Pad2_ Net-_Q11-Pad3_ BC327
Q10 Net-_Q10-Pad1_ /555TimerChip/Pin_Threshold Net-_Q10-Pad3_ BC327
Q13 GND Net-_Q13-Pad2_ Net-_Q12-Pad2_ BC327
R6 Net-_Q10-Pad1_ GND 100k
R9 Net-_Q13-Pad2_ GND 5k
R8 /555TimerChip/Pin_FMCV Net-_Q13-Pad2_ 5k
R7 /555TimerChip/Pin_Reset /555TimerChip/Pin_FMCV 5k
Q15 Net-_Q15-Pad1_ Net-_Q10-Pad1_ GND BC337
Q16 Net-_Q16-Pad1_ Net-_Q15-Pad1_ GND BC337
Q17 Net-_Q17-Pad1_ Net-_Q16-Pad1_ GND BC337
DQ18 Net-_Q18-Pad1_ Net-_Q16-Pad1_ 1N4007
Q25 Net-_Q14-Pad2_ /555TimerChip/Pin_Reset Net-_Q18-Pad1_ BC327
Q14 NC_01 Net-_Q14-Pad2_ GND BC337
R11 Net-_Q15-Pad1_ Net-_Q17-Pad1_ 4.7k
R16 Net-_Q14-Pad2_ Net-_Q20-Pad3_ 100
Q20 Net-_Q20-Pad1_ Net-_Q17-Pad1_ Net-_Q20-Pad3_ BC337
Q24 /output Net-_Q24-Pad2_ GND BC337
Q21 /555TimerChip/Pin_Reset Net-_Q20-Pad1_ Net-_Q21-Pad3_ BC337
Q22 /555TimerChip/Pin_Reset Net-_Q21-Pad3_ /output BC337
R12 /555TimerChip/Pin_Reset Net-_Q20-Pad1_ 6.8k
DQ23 /output Net-_Q20-Pad1_ 1N4007
R14 Net-_Q20-Pad3_ Net-_Q24-Pad2_ 220
R15 Net-_Q20-Pad3_ GND 4.7k
R13 Net-_Q21-Pad3_ /output 3.9k
Q19A1 Net-_Q19A1-Pad1_ Net-_Q19A1-Pad1_ /555TimerChip/Pin_Reset BC327
Q19B1 Net-_Q17-Pad1_ Net-_Q19A1-Pad1_ /555TimerChip/Pin_Reset BC327
.tran 10m 2000m 0
.end
